# Keil uVision project ucos_expt.uvproj, settings and files
target STM32F103 simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ucos_expt
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\include;.\uCOS-II\Source;.\uCOS-II\Ports
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group bsp files
    ./bsp/: Retarget.c Serial.c system_stm32f10x.c Time.c startup_stm32f10x_md.s
  group ucos-ii files
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group app files
    ./src/: traffic_light_main.c
